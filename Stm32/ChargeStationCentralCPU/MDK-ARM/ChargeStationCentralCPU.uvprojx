# Keil uVision project ChargeStationCentralCPU.uvprojx, settings and files
target ChargeStationCentralCPU (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ChargeStationCentralCPU +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;           ../Middlewares/Third_Party/LwIP/src/include;           ../Middlewares/Third_Party/LwIP/system;           ../Drivers/STM32F4xx_HAL_Driver/Inc;           ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;           ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;           ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;           ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;           ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;           ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;           ../Middlewares/Third_Party/FreeRTOS/Source/include;           ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;           ../Middlewares/Third_Party/LwIP/src/include/lwip;           ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;           ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;           ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;           ../Middlewares/Third_Party/LwIP/src/include/netif;           ../Middlewares/Third_Party/LwIP/src/include/posix;           ../Middlewares/Third_Party/LwIP/src/include/posix/sys;           ../Middlewares/Third_Party/LwIP/system/arch;           ../Drivers/CMSIS/Include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c timers.c queue.c list.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal.c stm32f4xx_hal_rng.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: ethernetif.c usbd_cdc_if.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c lwip.c usb_device.c usbd_conf.c freertos.c usbd_desc.c RFID.c rc522.c display.c lcd_hd44780_i2c.c channel.c rng.c settings.c serial_control.c chargePointTime.c net.c log.c webSocket.c base64.c rpc.c occp.c cJSON.c ocpp-json.c netEth.c netConn.c ocppConfiguration.c ocppConfigurationDef.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c netbuf.c err.c api_msg.c netifapi.c tcpip.c sockets.c netdb.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: chap-md5.c fsm.c ccp.c ipv6cp.c upap.c eui64.c utils.c mppe.c vj.c auth.c pppol2tp.c ppp.c ipcp.c pppcrypt.c magic.c chap-new.c multilink.c ecp.c demand.c eap.c pppapi.c chap_ms.c lcp.c pppoe.c pppos.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_out.c tcp_in.c ip.c pbuf.c timeouts.c netif.c mem.c def.c sys.c raw.c memp.c stats.c dns.c inet_chksum.c udp.c tcp.c init.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6.c ip6_frag.c icmp6.c nd6.c ethip6.c ip6_addr.c mld6.c dhcp6.c inet6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c ip4_frag.c igmp.c ip4.c ip4_addr.c etharp.c icmp.c dhcp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
software components: CMSIS:CORE 4.1.0, Compiler:I/O:STDOUT 1.0.0
